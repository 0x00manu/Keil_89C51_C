# Keil uVision project AND_Jumbo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: AND_Jumbo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: combined.c display.c lookup_table.c main.c serial.c timer0.c
